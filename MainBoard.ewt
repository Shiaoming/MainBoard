<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>DEBUG</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>FLASH</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\App\ArmFan.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\App\ArmFan.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\App\CANQueue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\App\CANQueue.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\App\GP2Y0A21YK0F.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\App\GP2Y0A21YK0F.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\App\Speed.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\App\Speed.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\Sysinit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\Sysinit.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\App\TASK.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\App\TASK.h</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <file>
      <name>$PROJ_DIR$\BSP\Src\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Inc\adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Src\BSP.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Inc\BSP.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Src\BSPMisc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Inc\BSPMisc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Src\Can1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Inc\Can1.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Src\Can2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Inc\Can2.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Inc\GYRO.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Inc\GYRO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Src\oled.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Inc\oled.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Src\PS_Driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Inc\PS_Driver.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Src\Usart1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\Inc\Usart1.h</name>
    </file>
  </group>
  <group>
    <name>CM4</name>
    <file>
      <name>$PROJ_DIR$\CMSIS\system_stm32f4xx.c</name>
    </file>
  </group>
  <group>
    <name>Documents</name>
    <file>
      <name>$PROJ_DIR$\Readme.txt</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Documents\&#x53C2;&#x8003;&#x6587;&#x6863;.txt</name>
    </file>
  </group>
  <group>
    <name>DSP_Lib</name>
    <group>
      <name>Compile</name>
      <file>
        <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_add_f32.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DSP_Lib\FastMathFunctions\arm_cos_f32.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_mult_f32.c</name>
      </file>
    </group>
    <group>
      <name>UnCompile</name>
      <group>
        <name>BasicMathFunctions</name>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_abs_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_abs_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_abs_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_abs_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_add_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_add_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_add_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_dot_prod_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_dot_prod_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_dot_prod_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_dot_prod_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_mult_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_mult_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_mult_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_negate_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_negate_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_negate_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_negate_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_offset_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_offset_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_offset_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_offset_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_scale_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_scale_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_scale_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_scale_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_shift_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_shift_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_shift_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_sub_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_sub_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_sub_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\BasicMathFunctions\arm_sub_q7.c</name>
        </file>
      </group>
      <group>
        <name>CommonTables</name>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\CommonTables\arm_common_tables.c</name>
        </file>
      </group>
      <group>
        <name>ComplexMathFunctions</name>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_conj_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_conj_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_conj_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_dot_prod_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_dot_prod_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_dot_prod_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_mag_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_mag_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_mag_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_mag_squared_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_mag_squared_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_mag_squared_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_mult_cmplx_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_mult_cmplx_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_mult_cmplx_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_mult_real_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_mult_real_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ComplexMathFunctions\arm_cmplx_mult_real_q31.c</name>
        </file>
      </group>
      <group>
        <name>ControllerFunctions</name>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ControllerFunctions\arm_pid_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ControllerFunctions\arm_pid_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ControllerFunctions\arm_pid_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ControllerFunctions\arm_pid_reset_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ControllerFunctions\arm_pid_reset_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ControllerFunctions\arm_pid_reset_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ControllerFunctions\arm_sin_cos_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\ControllerFunctions\arm_sin_cos_q31.c</name>
        </file>
      </group>
      <group>
        <name>FastMathFunctions</name>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FastMathFunctions\arm_cos_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FastMathFunctions\arm_cos_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FastMathFunctions\arm_sin_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FastMathFunctions\arm_sin_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FastMathFunctions\arm_sqrt_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FastMathFunctions\arm_sqrt_q31.c</name>
        </file>
      </group>
      <group>
        <name>FilteringFunctions</name>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_biquad_cascade_df1_32x64_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_biquad_cascade_df1_32x64_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_biquad_cascade_df1_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_biquad_cascade_df1_fast_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_biquad_cascade_df1_fast_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_biquad_cascade_df1_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_biquad_cascade_df1_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_biquad_cascade_df1_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_biquad_cascade_df1_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_biquad_cascade_df1_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_biquad_cascade_df2T_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_biquad_cascade_df2T_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_fast_opt_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_fast_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_fast_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_opt_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_opt_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_partial_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_partial_fast_opt_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_partial_fast_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_partial_fast_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_partial_opt_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_partial_opt_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_partial_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_partial_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_partial_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_conv_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_correlate_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_correlate_fast_opt_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_correlate_fast_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_correlate_fast_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_correlate_opt_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_correlate_opt_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_correlate_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_correlate_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_correlate_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_decimate_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_decimate_fast_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_decimate_fast_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_decimate_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_decimate_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_decimate_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_decimate_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_decimate_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_fast_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_fast_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_init_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_interpolate_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_interpolate_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_interpolate_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_interpolate_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_interpolate_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_interpolate_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_lattice_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_lattice_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_lattice_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_lattice_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_lattice_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_lattice_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_sparse_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_sparse_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_sparse_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_sparse_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_sparse_init_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_sparse_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_sparse_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_fir_sparse_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_iir_lattice_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_iir_lattice_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_iir_lattice_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_iir_lattice_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_iir_lattice_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_iir_lattice_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_lms_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_lms_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_lms_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_lms_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_lms_norm_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_lms_norm_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_lms_norm_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_lms_norm_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_lms_norm_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_lms_norm_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_lms_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\FilteringFunctions\arm_lms_q31.c</name>
        </file>
      </group>
      <group>
        <name>MatrixFunctions</name>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_add_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_add_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_add_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_inverse_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_mult_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_mult_fast_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_mult_fast_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_mult_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_mult_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_scale_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_scale_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_scale_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_sub_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_sub_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_sub_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_trans_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_trans_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\MatrixFunctions\arm_mat_trans_q31.c</name>
        </file>
      </group>
      <group>
        <name>StatisticsFunctions</name>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_max_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_max_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_max_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_max_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_mean_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_mean_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_mean_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_mean_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_min_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_min_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_min_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_min_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_power_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_power_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_power_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_power_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_rms_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_rms_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_rms_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_std_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_std_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_std_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_var_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_var_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\StatisticsFunctions\arm_var_q31.c</name>
        </file>
      </group>
      <group>
        <name>SupportFunctions</name>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_copy_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_copy_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_copy_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_copy_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_fill_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_fill_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_fill_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_fill_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_float_to_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_float_to_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_float_to_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_q15_to_float.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_q15_to_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_q15_to_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_q31_to_float.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_q31_to_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_q31_to_q7.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_q7_to_float.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_q7_to_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\SupportFunctions\arm_q7_to_q31.c</name>
        </file>
      </group>
      <group>
        <name>TransformFunctions</name>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_bitreversal.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_bitreversal2.S</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_radix2_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_radix2_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_radix2_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_radix2_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_radix2_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_radix2_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_radix4_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_radix4_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_radix4_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_radix4_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_radix4_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_radix4_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_cfft_radix8_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_dct4_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_dct4_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_dct4_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_dct4_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_dct4_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_dct4_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_rfft_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_rfft_fast_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_rfft_fast_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_rfft_init_f32.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_rfft_init_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_rfft_init_q31.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_rfft_q15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DSP_Lib\TransformFunctions\arm_rfft_q31.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\DSP_Lib\FastMathFunctions\arm_sin_f32.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>FWLib</name>
    <group>
      <name>Compile</name>
      <file>
        <name>$PROJ_DIR$\FWLib\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_usart.c</name>
      </file>
    </group>
    <group>
      <name>UnCompile</name>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_cryp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_cryp_aes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_cryp_des.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_cryp_tdes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_dcmi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_dma2d.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_hash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_hash_md5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_hash_sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_ltdc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_rng.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_sai.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FWLib\src\stm32f4xx_wwdg.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\USER\stm32f4xx_conf.h</name>
    </file>
  </group>
  <group>
    <name>Startup</name>
    <file>
      <name>$PROJ_DIR$\CMSIS\startup\startup_stm32f40_41xxx.s</name>
    </file>
  </group>
  <group>
    <name>uCOSIII</name>
    <group>
      <name>uC-CPU</name>
      <group>
        <name>Cfg</name>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uC-CPU\Cfg\cpu_cfg.h</name>
        </file>
      </group>
      <group>
        <name>Ports</name>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uC-CPU\Ports\cpu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uC-CPU\Ports\cpu_a.asm</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uC-CPU\Ports\cpu_c.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\uCOS-III\uC-CPU\cpu_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\uCOS-III\uC-CPU\cpu_core.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\uCOS-III\uC-CPU\cpu_def.h</name>
      </file>
    </group>
    <group>
      <name>uC-LIB</name>
      <group>
        <name>Cfg</name>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uC-LIB\Cfg\lib_cfg.h</name>
        </file>
      </group>
      <group>
        <name>Ports</name>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uC-LIB\Ports\lib_mem_a.asm</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\uCOS-III\uC-LIB\lib_ascii.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\uCOS-III\uC-LIB\lib_ascii.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\uCOS-III\uC-LIB\lib_def.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\uCOS-III\uC-LIB\lib_math.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\uCOS-III\uC-LIB\lib_math.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\uCOS-III\uC-LIB\lib_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\uCOS-III\uC-LIB\lib_mem.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\uCOS-III\uC-LIB\lib_str.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\uCOS-III\uC-LIB\lib_str.h</name>
      </file>
    </group>
    <group>
      <name>uCOS-III</name>
      <group>
        <name>Cfg</name>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Cfg\os_app_hooks.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Cfg\os_app_hooks.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Cfg\os_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Cfg\os_cfg_app.h</name>
        </file>
      </group>
      <group>
        <name>Ports</name>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Ports\os_cpu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Ports\os_cpu_a.asm</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Ports\os_cpu_c.c</name>
        </file>
      </group>
      <group>
        <name>Source</name>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_cfg_app.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_core.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_dbg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_flag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_int.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_mem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_msg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_mutex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_pend_multi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_prio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_q.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_sem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_stat.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_task.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_tick.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_time.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_tmr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_type.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\uCOS-III\uCOS-III\Source\os_var.c</name>
        </file>
      </group>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\USER\includes.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\USER\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\USER\stm32f4xx_it.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\USER\stm32f4xx_it.h</name>
  </file>
</project>


